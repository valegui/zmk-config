## boards/shields/kxn_hitbox/Kconfig.defconfig
```kconfig
if SHIELD_KXN_HITBOX

config ZMK_KEYBOARD_NAME
    default "kxn_hitbox"

endif # SHIELD_KXN_HITBOX
```
